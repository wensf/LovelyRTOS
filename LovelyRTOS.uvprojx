# Keil uVision project LovelyRTOS.uvprojx, settings and files
target V1.0.0 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LovelyRTOS
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx
  c include: .\Application\FWLIB\CMSIS\Include;.\Application\FWLIB\CMSIS\Device\ST\STM32F4xx\Include;.\Application\FWLIB\STM32F4xx_StdPeriph_Driver\inc;.\Application\Application;.\Application\RTOS;.\Application\Driver;.\Application\Task;.\Application\LovelyWin;.\Application\Component;.\Application\Driver;.\Application\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ./Application/Application/: main.c
  group RTOS
    ./Application/RTOS/: CPU.s CPU_Port.c OSTask.c OSCore.c
  group Component
    ./Application/Component/: LRT_Object.c LRT_Driver.c
  group Driver
    ./Application/Driver/: LRT_LED.c
  group Task
    ./Application/Task/: Task_LED.c Task_GUI.c
  group LovelyWin
    ./Application/LovelyWin/: Draw.c
  group BSP
    ./Application/BSP/: BSP_LED.c
  group FWLIB
    ./Application/FWLIB/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_spi.c stm32f4xx_adc.c misc.c
  group CMSIS
    ./Application/FWLIB/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./Application/FWLIB/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
